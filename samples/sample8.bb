H: NUMBER = !1;
D: NUMBER = 1 <= 2;
C: NUMBER = 1 + 2;
B: NUMBER = !(10 && 3) || 2 + !10 + !!2;
A: NUMBER = 1 + 2 && 3 * 4 % 5 * (6 / 7) || 8;
E: NUMBER = 3 ^ 2.5;
S: STRING = "HELLO WORLD";

PUT "ABC";
PUT H;
PUT D;
PUT E;
PUT S;
S = "hello world";
PUT S;
E = 5 ^ 5;
PUT E;
